
VERSION ""


NS_ : 
	NS_DESC_
	CM_
	BA_DEF_
	BA_
	VAL_
	CAT_DEF_
	CAT_
	FILTER
	BA_DEF_DEF_
	EV_DATA_
	ENVVAR_DATA_
	SGTYPE_
	SGTYPE_VAL_
	BA_DEF_SGTYPE_
	BA_SGTYPE_
	SIG_TYPE_REF_
	VAL_TABLE_
	SIG_GROUP_
	SIG_VALTYPE_
	SIGTYPE_VALTYPE_
	BO_TX_BU_
	BA_DEF_REL_
	BA_REL_
	BA_DEF_DEF_REL_
	BU_SG_REL_
	BU_EV_REL_
	BU_BO_REL_
	SG_MUL_VAL_

BS_:

BU_:BO_ 16 AccelPedals:  Vector__XXX
BO_ 17 SteeringPot:  Vector__XXX
BO_ 18 FrontBrakeSensor:  Vector__XXX
BO_ 19 RearBrakeSensor:  Vector__XXX
BO_ 35 ShockPotFront:  Vector__XXX
BO_ 36 ShockPotRear:  Vector__XXX
BO_ 240 WheelSpeed_FrontLeft:  Vector__XXX
BO_ 241 WheelSpeed_FrontRight:  Vector__XXX
BO_ 242 WheelSpeed_BackLeft:  Vector__XXX
BO_ 243 WheelSpeed_BackRight:  Vector__XXX
BO_ 245 ToggleSpeed_Front:  Vector__XXX
BO_ 246 ToggleSpeed_Back:  Vector__XXX
BO_ 247 ToggleSpeed_FrontRaw:  Vector__XXX
BO_ 248 ToggleSpeed_BackRaw:  Vector__XXX
BO_ 2045 CanSpecHash:  Vector__XXX
BO_ 2046 GitHash:  Vector__XXX
BO_ 2047 SrcHash:  Vector__XXX
BA_DEF_  "MultiplexExtEnabled" ENUM  "No","Yes";
BA_DEF_  "BusType" STRING ;
BA_DEF_DEF_  "MultiplexExtEnabled" "No";
BA_DEF_DEF_  "BusType" "CAN";